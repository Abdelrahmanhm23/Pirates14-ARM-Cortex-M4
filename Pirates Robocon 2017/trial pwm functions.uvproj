# Keil uVision project trial pwm functions.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: trial pwm functions
  c flags: Optim=1 wLevel=1
  c include: E:\Keil\TivaWare_C_Series-2.1.2.111\inc;E:\Keil\TivaWare_C_Series-2.1.2.111
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: MemMap.h MotorInit.h main.c MotorInit.c encoders.c PID.c UART.c startup_TM4C123.s Motion.c ssi.c spi.c pistons.c pistons.h ADC.c ADC.h Serve.c Serve.h Poles.c Poles.h fence.c
