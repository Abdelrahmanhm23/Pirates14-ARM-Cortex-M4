# Keil uVision project spi tiva slave.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: spi tiva slave
  c flags: Optim=1
  c include: E:\Keil\TivaWare_C_Series-2.1.2.111
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s spi slave.c MemMap.h ssi.c
